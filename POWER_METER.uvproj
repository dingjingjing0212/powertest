# Keil uVision project POWER_METER.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x58RD SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x7FFF) CLOCK(40000000)
  output: POWER_METER +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 POWER_METER_main.c
    ./IIC/: IIC.c
    ./Common/: common.c
    ./LCD1602/: LCD1602.c
    ./INA219_DRV/: INA219_DRV.c
